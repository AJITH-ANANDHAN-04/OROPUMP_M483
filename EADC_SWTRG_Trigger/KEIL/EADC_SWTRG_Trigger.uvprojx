# Keil uVision project EADC_SWTRG_Trigger.uvprojx, settings and files
target EADC_SWTRG_Trigger (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M483SIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: EADC_SWTRG_Trigger +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c RunMotor.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c eadc.c gpio.c lcd.c Rtc_I2c.c i2c.c
    ../../../../../../M480_BSP_CMSIS_V3.05.004/Library/StdDriver/src/: timer.c fmc.c
    ../../../../Library/StdDriver/inc/: i2c.h
software components: CMSIS:CORE 5.6.0
